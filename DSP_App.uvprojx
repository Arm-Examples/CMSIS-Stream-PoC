# Keil uVision project DSP_App.uvprojx, settings and files
target SIM DSP (6190000::V6.19::ARMCLANG)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.7.1
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: DSP_App
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: ARM_MATH_CM3 __Q15
  c misc: -g
  c include: .\ComputeGraph;./
  memory RVCT4: ROM 0x0 size 0x13880
  memory RVCT9: RAM 0x10000000 size 0xf000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source
    ./: DAC.c DSP_App.c DSP_FIR.c DSP_IIR.c Timer.c ADC.c
  group Documentation
    ./: Abstract.txt
  group ComputeGraph
    ./ComputeGraph/: dsp_scheduler.cpp dsp_scheduler.h DspNodes.h globalCGSettings.h IIR.h params.h
software components: CMSIS:CORE 5.6.0, CMSIS:DSP 1.14.4, CMSIS:DSP:Compute Graph 1.14.4, CMSIS:RTOS2:Keil RTX5 5.5.4, Compiler:Event Recorder 1.5.1, Compiler:I/O:STDOUT 1.2.0, Device:Startup 1.0.0
